# IAR project Project.ewp, settings and files
configuration STM32F401RE_Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DTLS_ROLE_SERVER=1; WITH_DTLS_COAP=0; NDEBUG; DTLS_PEERS_NOHASH=1; DTLS_CHECK_CONTENTTYPE; DTLSv12; WITH_SHA256; USE_LWM2M_FORMAT_FOR_DATAPOINT_NAME=0; X_NUCLEO_IDS01A4; IBM_BLUEMIX; USE_USART2; PROJECT_CONF_H=1; COMPILE_SENSORS=0; CONSOLE_UART_ENABLED; SPWF01; STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; USE_SPIRIT1_DEFAULT; WITH_UIP6; WITH_UIP; CONTIKI=1; UIP_CONF_TCP=1; NETSTACK_CONF_WITH_IPV6=1; UIP_CONF_IPV6_RPL=1; AUTOSTART_ENABLE=1; USART_PRINT_MSG; USE_X_CUBE_IDW01M1; REST=REGISTERED_ENGINE_ERBIUM; WIFI_CONFIG_VIA_MINI_AP; DISABLE_UNWANTED_PRINTF
  ICCARM.IExtraOptions: --diag_suppress=Pa089; --diag_suppress=Pe188; --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Utils; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW0xx1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\lib; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\er-coap; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\rest-engine; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\ipso-objects; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\oma-lwm2m; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\json; ..\..\..\..\..\..\Middlewares\Third_Party\MQTT-Paho\MQTTClient-C\src; ..\..\..\..\..\..\Middlewares\Third_Party\MQTT-Paho\MQTTPacket\src; ..\..\..\..\..\..\Middlewares\Third_Party\MQTT-Paho\Porting; ..\..\..\..\..\..\Middlewares\Third_Party\MQTT-Paho\Utils; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\tinydtls; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\tinydtls\aes; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\tinydtls\ecc; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\tinydtls\platform-specific; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\tinydtls\sha2
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F4xx-SGTW-LWM2M-to-IBM.bin
  ILINK.IlinkOutputFile: STM32F4xx-SGTW-LWM2M-to-IBM.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../../: readme.txt
  group Drivers/BSP/SPIRIT1
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/BSP/X-NUCLEO-IDW0xx1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW0xx1/: stm32_spwf_wifi.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_utils.c
  group Example/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xe.s
  group Example/User
    ../../Src/: console.c cube_hal_f4.c IBM_Bluemix_Config.c lwm2m-data.c lwm2m-resource-directory.c lwm2m-simple-server.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c wifi_support.c
  group Middlewares/Contiki/apps/er-coap
    ../../../../../../Middlewares/Third_Party/Contiki/apps/er-coap/: er-coap-block1.c er-coap-dtls.c er-coap-engine.c er-coap-observe-client.c er-coap-observe.c er-coap-res-well-known-core.c er-coap-separate.c er-coap-transactions.c er-coap-udp.c er-coap.c
  group Middlewares/Contiki/apps/json
    ../../../../../../Middlewares/Third_Party/Contiki/apps/json/: jsonparse.c
  group Middlewares/Contiki/apps/oma-lwm2m
    ../../../../../../Middlewares/Third_Party/Contiki/apps/oma-lwm2m/: lwm2m-object.c lwm2m-plain-text.c oma-tlv-reader.c oma-tlv-writer.c oma-tlv.c
  group Middlewares/Contiki/apps/rest-engine
    ../../../../../../Middlewares/Third_Party/Contiki/apps/rest-engine/: rest-engine.c
  group Middlewares/Contiki/apps/tinydtls
    ../../../../../../Middlewares/Third_Party/Contiki/apps/tinydtls/: ccm.c crypto.c dtls.c dtls_debug.c dtls_time.c hmac.c netq.c peer.c session.c
    ../../../../../../Middlewares/Third_Party/Contiki/apps/tinydtls/ecc/: ecc.c test_helper.c
    ../../../../../../Middlewares/Third_Party/Contiki/apps/tinydtls/aes/: rijndael.c
    ../../../../../../Middlewares/Third_Party/Contiki/apps/tinydtls/sha2/: sha2.c
  group Middlewares/Contiki/core/dev
    ../../../../../../Middlewares/Third_Party/Contiki/core/dev/: leds.c
  group Middlewares/Contiki/core/lib
    ../../../../../../Middlewares/Third_Party/Contiki/core/lib/: list.c memb.c random.c sensors.c
  group Middlewares/Contiki/core/net
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/: link-stats.c linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c
  group Middlewares/Contiki/core/net/ip
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ip/: ip64-addr.c psock.c resolv.c simple-udp.c tcpip.c udp-socket.c uip-debug.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group Middlewares/Contiki/core/net/ipv6
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group Middlewares/Contiki/core/net/llsec
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group Middlewares/Contiki/core/net/mac
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/: csma.c frame802154.c frame802154e-ie.c framer-802154.c framer-nullmac.c mac-sequence.c mac.c nordc.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c
  group Middlewares/Contiki/core/net/rpl
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-of0.c rpl-timers.c rpl.c
  group Middlewares/Contiki/core/sys
    ../../../../../../Middlewares/Third_Party/Contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c timer.c
  group Middlewares/Contiki_STM32_Library
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/dev/: button-sensor.c leds-arch.c radio-sensor.c
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/Src/: clock.c console.c contiki-spirit1-main.c node-id.c rtimer-arch.c spirit1-arch.c spirit1.c watchdog.c
  group Middlewares/MQTT-Paho/MQTTClient-C
    ../../../../../../Middlewares/Third_Party/MQTT-Paho/MQTTClient-C/src/: MQTTClient.c
  group Middlewares/MQTT-Paho/MQTTPacket
    ../../../../../../Middlewares/Third_Party/MQTT-Paho/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Middlewares/MQTT-Paho/Porting
    ../../../../../../Middlewares/Third_Party/MQTT-Paho/Porting/: MQTT_SPWF_interface.c
  group Middlewares/MQTT-Paho/Utils
    ../../../../../../Middlewares/Third_Party/MQTT-Paho/Utils/: TLocalBuffer.c
  group Middlewares/STM32_SPWF0xSy
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/: wifi_interface.c wifi_module.c wifi_module_spi.c wifi_module_uart_01.c wifi_module_uart_04.c
  group Middlewares/STM32_SPWF0xSy/Utils
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/Utils/: event_buffer.c ring_buffer.c spwf04WiFi.c wifi_globals.c
